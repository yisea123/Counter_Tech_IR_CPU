# Keil uVision project Counter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Counter_Tech_IR_CPU +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf -c ".\Objects\@L.axf" -o  ".\@L.asm"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\driver;.\HARDWARE\TIMER;.\AD_Sample;.\SYSTEM\delay;.\Cmd;.\SYSTEM\sys;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\Protocol;.\FATFS\src;.\Counter_system;.\Fill_bottle_system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\Counter.sct
  link misc: --keep=my_cmd.o(my_cmd_sec)
  group user
    ./user/: main.c log.c
  group driver
    ./driver/: led.c dac.c usart.c drive_io.h driver_io.c rtc.c w25qxx.c spi.c stm32flash.c stm32flash.h ad8804.c ad8804.h
  group my_printf
    ./my_printf/: retarget.c
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group Cmd
    ./Cmd/: my_cmd.c MD5.c
  group UCOSII-CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII-PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Protocol
    ./Protocol/: ModbusRTU.h ModbusRTU.c
  group AD_Sample
    ./AD_Sample/: AD_Sample.c AD_Sample.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
